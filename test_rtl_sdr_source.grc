options:
  parameters:
    generate_options: qt_gui
    id: test_rtl_sdr_source
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: fft_size
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: freq_mhz
  id: variable_qtgui_range
  parameters:
    start: '89'
    step: '1'
    stop: '800'
    value: '90'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '50'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: fft_size
    grid: 'True'
    legend: 'False'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: fft_size
    legend: 'False'
    type: complex
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '0'
    freq0: freq_mhz*1e6
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
