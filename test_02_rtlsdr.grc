options:
  parameters:
    generate_options: qt_gui
    id: test_02_rtlsdr
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: frequency_mhz
  id: variable_qtgui_entry
  parameters:
    label: Frequency [MHz]
    type: real
    value: '390.000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2560000'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,0,1,2
    legend: 'False'
    name: '"Rtl#1 Receive Signal"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0,0,1,2
    legend: 'False'
    name: '"BB Receive Signal"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: rtl=0
    bb_gain0: '0'
    freq0: int(frequency_mhz*1e6)
    gain0: '1'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: rtlsdr_source_0_0
  id: rtlsdr_source
  parameters:
    args: rtl=1
    bb_gain0: '0'
    freq0: int(frequency_mhz*1e6)
    gain0: '1'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [rtlsdr_source_0, '0', qtgui_time_sink_x_0, '0']
- [rtlsdr_source_0_0, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
