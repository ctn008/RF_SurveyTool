options:
  parameters:
    generate_options: qt_gui
    id: test1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: auto_gain
  id: variable_qtgui_toggle_switch
  parameters:
    initPressed: 'False'
    pressed: '1'
    released: '0'
    type: bool
    value: '0'
  states: {}
- name: decim_rate
  id: variable
  parameters:
    value: '32'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    start: '-4000'
    step: '100'
    stop: '4000'
    value: '3800'
  states: {}
- name: gain_values
  id: variable
  parameters:
    value: (0.0, 0.9, 1.4, 2.7, 3.7, 7.7, 8.7, 12.5, 14.4, 15.7, 16.6, 19.7, 20.7, 22.9, 25.4, 28.0, 29.7, 32.8, 33.8, 36.4, 37.2, 38.6, 40.2, 42.1, 43.4, 43.9, 44.5, 48.0, 49.6)
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: len(gain_values)-1
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2560000'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: byte
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/ctn008/RfSurvey/rrbb_samples/s2m56_gidx20_iq03.int8
    type: byte
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: 16384*160*30
    type: byte
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: 2560000 * 2
    type: byte
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    type: byte
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Input:
      - a block of IQ samples in bytes default 16384 bytes
      Output:
      - histogram for I & Q signal in float32"""

      import numpy as np
      from gnuradio import gr


      class my_decim_block(gr.decim_block):
          def __init__(self, decim_rate = 32):
              gr.decim_block.__init__(self,
                  name="Byte_Samples Histogram",
                  in_sig=[np.int8],
                  out_sig=[np.float32],
                  decim = decim_rate)
              self.set_relative_rate(1.0/decim_rate)
              self.decimation = decim_rate

          def work(self, input_items, output_items):
              in_len = len(input_items[0])
              out_len = 0
              while in_len >= 256 * self.decimation:
                  for i in range (256):
                      output_items[0][i] = 0
                  for i in range (256 * self.decimation):
                      output_items[0][out_len + 128 + input_items[0][i]  ] += 1 
                  in_len -= 256 * self.decimation
                  out_len += 256
              return out_len
    comment: |-
      In (byte)          : 8192 
      Out (float32) :   256
    decim_rate: decim_rate
  states: {state: disabled}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '256'
    name: '"I only"'
    size: 16384//2
    type: float
    xmax: '128'
    xmin: '-128'
  states: {}
- name: qtgui_histogram_sink_x_0_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '256'
    name: '"Q only"'
    size: 16384//2
    type: float
    xmax: '127'
    xmin: '-128'
  states: {}
- name: qtgui_histogram_sink_x_0_0_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '256'
    name: '"Mixed IQ"'
    size: '16384'
    type: float
    xmax: '127'
    xmin: '-128'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '256'
    srate: samp_rate/decim_rate
    type: float
    ymax: '128'
    ymin: '-128'
  states: {state: disabled}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    agc: auto_gain
    center_freq: '391250000'
    gain: gain_values[rf_gain]
    samp_rate: samp_rate
    type: sc8
  states: {}

connections:
- [blocks_char_to_float_0, '0', qtgui_histogram_sink_x_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_histogram_sink_x_0_0, '0']
- [blocks_char_to_float_0_1, '0', qtgui_histogram_sink_x_0_0_0, '0']
- [blocks_deinterleave_0, '0', blocks_char_to_float_0, '0']
- [blocks_deinterleave_0, '1', blocks_char_to_float_0_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_head_0, '0', blocks_null_sink_0, '0']
- [blocks_skiphead_0, '0', blocks_head_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_char_to_float_0_1, '0']
- [blocks_vector_to_stream_0, '0', blocks_deinterleave_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_skiphead_0, '0']
- [blocks_vector_to_stream_0, '0', epy_block_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_0, '0']
- [soapy_rtlsdr_source_0, '0', blocks_vector_to_stream_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
