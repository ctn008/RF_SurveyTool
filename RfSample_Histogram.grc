options:
  parameters:
    generate_options: qt_gui
    id: test2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: block_size
  id: variable
  parameters:
    value: '256'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2560000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/ctn008/myrtlsdr/build/abc/b95_s0_1735362734.uint8_histogram_int16
    repeat: 'True'
    type: short
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/ctn008/myrtlsdr/build/abc/b95_s1_1735362734.uint8_histogram_int16
    repeat: 'True'
    type: short
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_0_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: short
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: short
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: file1
    size: block_size
    srate: samp_rate
    type: float
    ymax: '2000'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: file2
    size: block_size
    srate: samp_rate
    type: float
    ymax: '2000'
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_file_source_0_0, '0', blocks_throttle2_0_0, '0']
- [blocks_short_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_short_to_float_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_throttle2_0, '0', blocks_short_to_float_0, '0']
- [blocks_throttle2_0_0, '0', blocks_short_to_float_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
